# Keil uVision project UART.uvprojx, settings and files
target STM32F429 (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,STM32F4XX
  c include: ..\..\..\STM32-Libraries\Peripheral\stm32f4_dsp_stdperiph_lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32-Libraries\Peripheral\stm32f4_dsp_stdperiph_lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\STM32F4xx_StdPeriph_Driver\src;..\..\..\STM32-Libraries\Peripheral\stm32f4_dsp_stdperiph_lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\STM32-Libraries\Peripheral\stm32f4_dsp_stdperiph_lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\..\..\STM32-Libraries\Peripheral\stm32f4_dsp_stdperiph_lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Include;..\UART
  asm include: ..\Project stm32f4 Template\Libraries\inc;..\Project stm32f4 Template\Libraries\src;..\Project stm32f4 Template\Include;..\Project stm32f4 Template\startup;..\Project stm32f4 Template\CMIS;..\Project stm32f4 Template\Source
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c
  group Libraries
    ../../../STM32-Libraries/Peripheral/stm32f4_dsp_stdperiph_lib/STM32F4xx_DSP_StdPeriph_Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group Startup
    ../../../STM32-Libraries/Peripheral/stm32f4_dsp_stdperiph_lib/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../../../STM32-Libraries/Peripheral/stm32f4_dsp_stdperiph_lib/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/Include/: core_cm4.h
    ./: system_stm32f4xx.c
